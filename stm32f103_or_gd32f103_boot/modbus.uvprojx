# Keil uVision project modbus.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: modbus +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\User\Option;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\flash;.\BSP\inc;.\APP\inc;.\Libraries\Include;.\Libraries
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./Startup/Startup/: startup_stm32f10x_md.s
    ./Libraries/CMSIS/: core_cm3.c
  group user
    ./User/: main.c stm32f10x_sys.c
    ./flash/: Flash_app.c
    ./BSP/: usart.c
    ./APP/: common.c
  group modbus
    ./APP/: modbus_ascii.c
  group stdlib
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c
    ./Libraries/CMSIS/: system_stm32f10x.c
